# Keil uVision project PWM_Complementary_DeadTime.uvproj, settings and files
target PWM_Complementary_DeadTime (MCS-51)
  device: MG51LD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: PWM_Complementary_DeadTime +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c pwm0.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
